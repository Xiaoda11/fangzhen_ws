Commit message: aaa

File: src/urdf02_gazebo/urdf/demo01_hello.urdf (robot description, URDF)
Before this commit: robot test1, 1 links, 0 joints
Links:
- removed link link_name
- added link base_link, mass 6; collision box size=0.5 0.2 0.1; visual box size=0.5 0.2 0.1
